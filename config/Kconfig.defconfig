## config/Kconfig.defconfig
```kconfig
if SHIELD_SCOTTOPAD

config ZMK_KEYBOARD_NAME
    default "Smart-tek PAD"

endif
```
